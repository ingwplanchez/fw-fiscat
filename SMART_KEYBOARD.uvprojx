# Keil uVision project SMART_KEYBOARD.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1114FHN33/333 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0xE000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SMART_KEYBOARD +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=SMART_KEYBOARD.bin SMART_KEYBOARD.axf
  AfterMake: BUILD2.bat
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0xe000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\LPC111x.sct
  group Source Group
    ./: pc.c clkconfig.c core_cm0.c F25L016A.c gpio.c keyscan.c spec12832.c spi1.c system_LPC11xx.c Timer.c uart.c startup_LPC11xx.s system.c mensajes.c display.c menu.c func.c func_plu.c cmd.c mem.c main.c keyboard.c reporte_plu.c reporte_plu.h
  group Include Group
    ./: Device.h core_cm0.h Event.h clkconfig.h F25L016A.h gpio.h hardware.h includes.h Keyscan.h LPC11xx.h msgdefine.h spec12832.h SPI1.h system_LPC11xx.h Timer.h timer16.h timer32.h type.h uart.h menu.h
